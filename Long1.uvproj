# Keil uVision project Long1.uvproj, settings and files
target Long1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PileCore +hex
  link misc: REMOVEUNUSED
  group Hardware
    ./Hardware/CalcDoseRate/: CalcDoseRate.c
    ./Hardware/Cmd/: CMD.c
    ./Hardware/Flash/: flash.c
    ./Hardware/IIC/: i2c.c
    ./Hardware/Mcp4725/: mcp4725.c
    ./Hardware/Sensor/: Sensor.c
    ./Hardware/System/: system.c
    ./Hardware/Uart/: uart.c
    ./Hardware/BatVoltage/: BatVoltage.c
    ./Hardware/CalcCps/: CalcCPS.c
    ./Hardware/DoseRate/: DoseRate.c
    ./Hardware/CRC/: CRC.c
    ./Hardware/Queue/: Queue.c
  group User
    ./User/: main.c
